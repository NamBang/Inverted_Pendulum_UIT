# Keil uVision project Project.uvprojx, settings and files
target STM32F429-LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\..\..\Stm32F429 library\CMSIS\Include;..\..\..\Stm32F429 library\My_Library\inc;..\..\..\Stm32F429 library\StartUp;..\..\..\Stm32F429 library\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Stm32F429 library\User;..\Inc;..\MDK-ARM;..\..\09_STM32F429_Encoder\Inc;..\Inc;..\..\..\Stm32F429 library\STM32F4xx_StdPeriph_Driver\inc
  asm define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  asm include: ..\..\..\Stm32F429 library\CMSIS\Include;..\..\..\Stm32F429 library\My_Library\inc;..\..\..\Stm32F429 library\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Stm32F429 library\User
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../../Stm32F429 library/CMSIS/src/: core_cm4.c system_stm32f4xx.c
  group StartUp
    ../../../Stm32F429 library/StartUp/: startup_stm32f429_439xx.s
  group StdPeriph_Drivers
    ../../../Stm32F429 library/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c misc.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_usart.c
  group User
    ../../../Stm32F429 library/User/: stm32f4xx_conf.h
    ./: main.c main.h
    ../Src/: stm32f4xx_it.c tm_stm32f4_delay.c B_stm32f4_tim.c pid_controller.c
    ../../../Stm32F429 library/My_Library/src/: B_stm32f4_gpio.c B_stm32f4_usart.c
